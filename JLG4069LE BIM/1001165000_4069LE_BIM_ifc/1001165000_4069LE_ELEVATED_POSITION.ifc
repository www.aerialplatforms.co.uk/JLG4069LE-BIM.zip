Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2018-03-15T16:48:07
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Mar 15 16:48:07 2018 * Host: CHTSP10141 * Database: C:\Users\20062089\AppData\Local\Temp\{129B4221-0333-4CB6-88D8-29667C83B8F8}\ifc * Database version: 5507 * Database creation date: Thu Mar 15 16:47:50 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Mar 15 16:47:50 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Mar 15 16:47:50 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Identity Data - Type Name: 8mm Head; Building Story: yes; Name: Level 1; Structural: no
Graphics - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm

# IfcTransportElement: Flat Surface, 1001165000_4069LE:Flat Surface:622236
In: Level 1
Type - PredefinedType: ELEVATOR; Material: JLG_Paint_Black, JLG_Paint_White, JLG_Paint_Orange, JLG_Plastic_Red, JLG_Plastic_Yellow, JLG_Paint_Beige, JLG_Steel, JLG_Rubber_Black
Type - Constraints - Platform_Extention: 1000 mm; Platform_Height: 13000 mm; Platform Extension Maximum: Max Extension 0.91m (3 ft 0 in); Platform Height Maximum: Max Height 12.19m (40 ft 0 in); Slope Value: 0 deg; Slope Value Maximum: User to define Slope; Transportation Condition: no
Type - Data - Batteries: 8 x 6v 370 Ah; Drive Motor: Dual Electric Traction; Drive Speed Elevator: 0.69 kph (0.43 mph); Drive Speed lowered: 5.15 kph (3.2 mph); Gradeability: 35%; Gross Vehicle Weight (ANSI): 4790 kg (10560 lbs); Gross Vehicle Weight (CE): 5216 kg (11500 lbs); Ground Clearance: 0.20 m (0 ft 8 in); Hydraulic Tank Capacity: 31.23 L (8.25 gal); Lift Up time: 52 sec; Lower down Time: 50 sec; Max Ground Bearing Pressure (ANSI): 4.29 kg/cm2 (61 psi); Max Ground Bearing Pressure (CE): 4.29 kg/cm2 (61 psi); Platform Capacity (ANSI): 362 kg (800 lbs); Platform Capacity (CE): 360 kg (794 lbs); Platform Extention Capacity (ANSI): 113 kg (250 lbs); Platform Extention Capacity (CE): 120 kg (264 lbs); Platform Extention Size ( L): 0.91 m (3 ft 0 in); Platform Height: 12.19 m (40 ft 0 in); Platform Size (W x L): 1.65 m x 2.92 m (5 ft 5 in x 9 ft 7 in); Turning Radius Inside: 2.29m (7 ft 6 in); Turning Radius Outside: 4.72m (15 ft 6 in); Tyres: 240/55 17.5 Foam Filled Non Marking
Type - Dimensions - F: no; L: no; L_Height: 0 mm; Leg1: 0 mm; Leg2: 0 mm; Leg3: 0 mm; Leg4: 0 mm; Length: 0 mm; Offset Height: 0 mm; Offset Length: 0 mm; R: no; Re: no; Slope: 0 deg
Type - General - Electric Scissor Lift: JLG_4069LE; Platform Extention Size: 0.91 m (3 ft 0 in); Platform Size: 1.65 m x 2.92 m (5 ft 5 in x 9 ft 7 in)
Type - Identity Data - Manufacturer: JLG; OmniClass Number: 23.40.00.00; OmniClass Title: Equipment and Furnishings; Type Name: Flat Surface; URL: https://www.jlg.com
Type - Model Properties - _Author: n/a; _AuthorizedBy: n/a; _BIMspec_GUID: n/a; _BimSpecGuid: n/a; _BSBibleVersion: n/a; _CreatedBy: JLG; _CurrentRevision: 0; _DistributedBy: JLG; BIMObjectName: 1001165000_4069LE; NBSDescription: Electric Scissor Lift; NBSNote: n/a; NBSObjectName: JLG_4069LE_Electric Scissor Lift; NBSOfficeMasterTag: n/a; NBSReference: n/a
Type - Other - Category: Mechanical Equipment; AccessibilityPerformance: n/a; AssetIdentifier (default): Please Record On Commissioning.; AssetType: Elevators; BarCode (default): Please Record On Commissioning.; ClassificationName: n/a; ClassificationValue: n/a; CodePerformance: n/a; Color: n/a; Constituents: n/a; CreatedBy: JLG (https://www.jlg.com/en); CreatedOn: 2018; DocumentationCertificates: n/a; DocumentationInstallationGuide: n/a; DocumentationLiterature: n/a; DocumentationMaintenance: n/a; DocumentationTechnical: n/a; DurationUnit: Years; ExpectedLife: n/a; Family Name: 1001165000_4069LE; Features: n/a; Finish: n/a; Grade: n/a; InstallationDate (default): n/a; ManufacturerName: JLG (https://www.jlg.com/en); Material: n/a; ModelNumber: 4069LE; ModelReference: JLG - Electric Scissor Lift; ProductionYear: n/a; ReferencedStandard: n/a; ReplacementCost: n/a; SerialNumber (default): Please Record On Commissioning; Shape: n/a; Size: n/a; SpareParts: n/a; TypeName: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Years; WarrantyGuarantorLabor: https://www.jlg.com; WarrantyGuarantorParts: https://www.jlg.com
OperationType: ELEVATOR; CapacityByWeight: 0 kg; CapacityByNumber: 0
Pset_ManufacturerTypeInformation - ModelReference: JLG - Electric Scissor Lift; Manufacturer: JLG; ProductionYear: n/a
Constraints - BWA: no; Extension Working Area: no; Height: 12034 mm; Host: Level : Level 1; Ht: 11224 mm; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm; Platform Length: 3834 mm; PS: 2920 mm; PX: 914 mm; Static: 966 mm; Turning Radius: no; Working Area: no
Dimensions - Area: 180.88 m2; Volume: 1.55902 m3
Identity Data - Mark: 24
Other - Family: 1001165000_4069LE: Flat Surface; Family and Type: 1001165000_4069LE: Flat Surface; Type: 1001165000_4069LE: Flat Surface; Type Id: 1001165000_4069LE: Flat Surface; WarrantyStartDate (default): Please Record On Commissioning.
Phasing - Phase Created: Phase 1
